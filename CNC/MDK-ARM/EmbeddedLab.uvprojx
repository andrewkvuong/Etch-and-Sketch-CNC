# Keil uVision project EmbeddedLab.uvprojx, settings and files
target EmbeddedLab (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F072RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: EmbeddedLab
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F072xB
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f072xb.s
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_cortex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_dma.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_i2c.c stm32f0xx_hal_flash.c stm32f0xx_hal_rcc.c stm32f0xx_hal_tim.c stm32f0xx_hal.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c
  group Application/User
    ../Src/: stm32f0xx_hal_msp.c main.c stm32f0xx_it.c motor_control.c motor_control.h stm_utils.c stm_utils.h
software components: CMSIS:CORE 4.3.0
